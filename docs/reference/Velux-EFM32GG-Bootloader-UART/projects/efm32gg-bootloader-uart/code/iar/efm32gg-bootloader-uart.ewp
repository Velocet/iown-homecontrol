# IAR project efm32gg-bootloader-uart.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32GG230F512 SiliconLaboratories EFM32GG230F512
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: EFM32GG230F512; BOOTLOADER_VERSION_STRING="2.00"
  ICCARM.CCIncludePath2: C:\gitdata\efm32gg-bootloader-uart\depends\gecko-sdk\code\platform\CMSIS\Include; C:\gitdata\efm32gg-bootloader-uart\depends\gecko-sdk\code\platform\Device\SiliconLabs\EFM32GG\Include; C:\gitdata\efm32gg-bootloader-uart\projects\efm32gg-bootloader-uart\code\bootloader; C:\gitdata\efm32gg-bootloader-uart\depends\gecko-sdk\code\platform\emlib\inc; C:\gitdata\efm32gg-bootloader-uart\projects\efm32gg-bootloader-uart\code\common; C:\gitdata\efm32gg-bootloader-uart\projects\efm32gg-bootloader-uart\code\decryption; C:\gitdata\efm32gg-bootloader-uart\depends\data-types
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFM32GG230F512; BOOTLOADER_VERSION_STRING="2.00"
  AARM.AUserIncludes: ..\..\..\Libraries\LIBRARY_Gecko_Sdk_v2.3\SourceCode\platform\CMSIS\Include; ..\..\..\Libraries\LIBRARY_Gecko_Sdk_v2.3\SourceCode\platform\Device\SiliconLabs\EFM32G\Include; ..\Bootloader; ..\Decryption
  OBJCOPY.OOCOutputFile: efm32gg-bootloader-uart.bin
  ILINK.IlinkOutputFile: efm32gg-bootloader-uart.out
  ILINK.IlinkIcfFile: iar_linker_files\EFM32GG230F512.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; EFM32GG230F512; BOOTLOADER_VERSION_STRING="2.00"
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: EFM32_Encrypted_Bootloader.bin
  ILINK.IlinkOutputFile: EFM32_Encrypted_Bootloader.out
  ILINK.IlinkIcfFile: iar_linker_files\EFM32G230F128.icf
  group bootloader
    ../bootloader/: autobaud.c boot.c bootloader.c crc.c debug.c debuglock.c flash.c iarwrite.c startup_efm32.s usart.c xmodem.c
  group common
    ../common/: Version.c
  group decryption
    ../decryption/: aes_ctr_128.c
  group emlib
    ../../../../depends/gecko-sdk/code/platform/emlib/src/: em_aes.c em_cmu.c em_emu.c em_system.c
