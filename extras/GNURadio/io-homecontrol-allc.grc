options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '38400'
  states: {}
- name: bingroup
  id: variable
  parameters:
    value: '1'
  states: {}
- name: fctr1
  id: variable
  parameters:
    value: 868.250e6
  states: {}
- name: fctr2
  id: variable
  parameters:
    value: 868.950e6
  states: {}
- name: fctr3
  id: variable
  parameters:
    value: 869.850e6
  states: {}
- name: fmid
  id: variable
  parameters:
    value: (fctr1+fctr2)/2
  states: {}
- name: hexgroup
  id: variable
  parameters:
    value: '4'
  states: {}
- name: hexorder
  id: variable
  parameters:
    value: '0'
  states: {}
- name: msglen
  id: variable
  parameters:
    value: '39'
  states: {}
- name: msgoffset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: showbin
  id: variable
  parameters:
    value: '0'
  states: {}
- name: showhex
  id: variable
  parameters:
    value: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fmid - fctr1
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fmid-fctr2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fmid-fctr3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: c:\temp\io_home_c2_qdemod_2_4M_cplx_cz.raw
    type: complex
    vlen: '3'
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: c:\temp\io_homecontrol_sliced_96k_byte_cx2.raw
    type: byte
    vlen: '3'
  states: {state: disabled}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: c:\temp\io_homecontrol_sliced_96k_byte_cx2.raw
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: c:\temp\io_raw.raw
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: byte
    vlen: '3'
  states: {state: disabled}
- name: blocks_streams_to_vector_0_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '3'
    type: byte
  states: {state: disabled}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: C:\temp\out.wav
    samp_rate: int(2*samp_rate/25)
  states: {state: disabled}
- name: io_home_demod_0
  id: io_home_demod
  parameters:
    fbaud: baud_rate
    samp_rate: samp_rate
  states: {}
- name: io_home_demod_0_0
  id: io_home_demod
  parameters:
    fbaud: baud_rate
    samp_rate: samp_rate
  states: {}
- name: io_home_demod_0_0_0
  id: io_home_demod
  parameters:
    fbaud: baud_rate
    samp_rate: samp_rate
  states: {}
- name: io_homecontrol_slicer_0
  id: io_homecontrol_slicer
  parameters:
    bingroup: bingroup
    channel: '1'
    hexgroup: hexgroup
    msglen: msglen
    msgoffset: msgoffset
    showbin: showbin
    showhex: showhex
    srate: 2*samp_rate/25
  states: {}
- name: io_homecontrol_slicer_0_0
  id: io_homecontrol_slicer
  parameters:
    bingroup: bingroup
    channel: '2'
    hexgroup: hexgroup
    msglen: msglen
    msgoffset: msgoffset
    showbin: showbin
    showhex: showhex
    srate: 2*samp_rate/25
  states: {}
- name: io_homecontrol_slicer_0_0_0
  id: io_homecontrol_slicer
  parameters:
    bingroup: bingroup
    channel: '3'
    hexgroup: hexgroup
    msglen: msglen
    msgoffset: msgoffset
    showbin: showbin
    showhex: showhex
    srate: 2*samp_rate/25
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '34800'
    srate: '192000'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: fmid
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: fmid
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_multiply_xx_0, '0', io_home_demod_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0_0, '0', io_home_demod_0_0, '0']
- [blocks_multiply_xx_0_0_0, '0', io_home_demod_0_0_0, '0']
- [blocks_streams_to_vector_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_streams_to_vector_0_0, '0', blocks_null_sink_1, '0']
- [io_home_demod_0, '0', blocks_null_sink_0, '0']
- [io_home_demod_0, '0', qtgui_waterfall_sink_x_0, '0']
- [io_home_demod_0, '1', blocks_file_sink_1, '0']
- [io_home_demod_0, '1', blocks_streams_to_vector_0_0, '2']
- [io_home_demod_0, '1', io_homecontrol_slicer_0, '0']
- [io_home_demod_0_0, '0', blocks_null_sink_0_0, '0']
- [io_home_demod_0_0, '1', blocks_streams_to_vector_0_0, '1']
- [io_home_demod_0_0, '1', io_homecontrol_slicer_0_0, '0']
- [io_home_demod_0_0_0, '0', blocks_null_sink_0_0_0, '0']
- [io_home_demod_0_0_0, '1', blocks_file_sink_0, '0']
- [io_home_demod_0_0_0, '1', blocks_file_sink_0_0_0, '0']
- [io_home_demod_0_0_0, '1', blocks_multiply_const_vxx_0, '0']
- [io_home_demod_0_0_0, '1', blocks_streams_to_vector_0_0, '0']
- [io_home_demod_0_0_0, '1', io_homecontrol_slicer_0_0_0, '0']
- [rtlsdr_source_0, '0', blocks_multiply_xx_0, '0']
- [rtlsdr_source_0, '0', blocks_multiply_xx_0_0, '0']
- [rtlsdr_source_0, '0', blocks_multiply_xx_0_0_0, '0']

metadata:
  file_format: 1
