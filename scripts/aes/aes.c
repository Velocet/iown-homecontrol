/*
 * aes.c
 *
 *  Created on: 08-10-2013
 *      Author: Tomek
 */


#include <string.h>
#include <stdint.h>

/* keep in mind that C uses rows as major indexing, and aes uses column 
 * major indexing so rows become columns and vice-versa  
 */

/* exponential funct in galois field 2^8 */
static const uint8_t rcon[10] = {
	0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 
	0x1b, 0x36
};

/* s-box */
static const uint8_t sbox[256] = {
	0x63, 0x7C, 0x77, 0x7B, 0xF2, 0x6B, 0x6F, 0xC5,
	0x30, 0x01, 0x67, 0x2B, 0xFE, 0xD7, 0xAB, 0x76,
	0xCA, 0x82, 0xC9, 0x7D, 0xFA, 0x59, 0x47, 0xF0,
	0xAD, 0xD4, 0xA2, 0xAF, 0x9C, 0xA4, 0x72, 0xC0,
	0xB7, 0xFD, 0x93, 0x26, 0x36, 0x3F, 0xF7, 0xCC,
	0x34, 0xA5, 0xE5, 0xF1, 0x71, 0xD8, 0x31, 0x15,
	0x04, 0xC7, 0x23, 0xC3, 0x18, 0x96, 0x05, 0x9A,
	0x07, 0x12, 0x80, 0xE2, 0xEB, 0x27, 0xB2, 0x75,
	0x09, 0x83, 0x2C, 0x1A, 0x1B, 0x6E, 0x5A, 0xA0,
	0x52, 0x3B, 0xD6, 0xB3, 0x29, 0xE3, 0x2F, 0x84,
	0x53, 0xD1, 0x00, 0xED, 0x20, 0xFC, 0xB1, 0x5B,
	0x6A, 0xCB, 0xBE, 0x39, 0x4A, 0x4C, 0x58, 0xCF,
	0xD0, 0xEF, 0xAA, 0xFB, 0x43, 0x4D, 0x33, 0x85,
	0x45, 0xF9, 0x02, 0x7F, 0x50, 0x3C, 0x9F, 0xA8,
	0x51, 0xA3, 0x40, 0x8F, 0x92, 0x9D, 0x38, 0xF5,
	0xBC, 0xB6, 0xDA, 0x21, 0x10, 0xFF, 0xF3, 0xD2,
	0xCD, 0x0C, 0x13, 0xEC, 0x5F, 0x97, 0x44, 0x17,
	0xC4, 0xA7, 0x7E, 0x3D, 0x64, 0x5D, 0x19, 0x73,
	0x60, 0x81, 0x4F, 0xDC, 0x22, 0x2A, 0x90, 0x88,
	0x46, 0xEE, 0xB8, 0x14, 0xDE, 0x5E, 0x0B, 0xDB,
	0xE0, 0x32, 0x3A, 0x0A, 0x49, 0x06, 0x24, 0x5C,
	0xC2, 0xD3, 0xAC, 0x62, 0x91, 0x95, 0xE4, 0x79,
	0xE7, 0xC8, 0x37, 0x6D, 0x8D, 0xD5, 0x4E, 0xA9,
	0x6C, 0x56, 0xF4, 0xEA, 0x65, 0x7A, 0xAE, 0x08,
	0xBA, 0x78, 0x25, 0x2E, 0x1C, 0xA6, 0xB4, 0xC6,
	0xE8, 0xDD, 0x74, 0x1F, 0x4B, 0xBD, 0x8B, 0x8A,
	0x70, 0x3E, 0xB5, 0x66, 0x48, 0x03, 0xF6, 0x0E,
	0x61, 0x35, 0x57, 0xB9, 0x86, 0xC1, 0x1D, 0x9E,
	0xE1, 0xF8, 0x98, 0x11, 0x69, 0xD9, 0x8E, 0x94,
	0x9B, 0x1E, 0x87, 0xE9, 0xCE, 0x55, 0x28, 0xDF,
	0x8C, 0xA1, 0x89, 0x0D, 0xBF, 0xE6, 0x42, 0x68,
	0x41, 0x99, 0x2D, 0x0F, 0xB0, 0x54, 0xBB, 0x16
};

/* inverted s-box */
static const uint8_t isbox[256] = {
    0x52, 0x09, 0x6a, 0xd5, 0x30, 0x36, 0xa5, 0x38, 
    0xbf, 0x40, 0xa3, 0x9e, 0x81, 0xf3, 0xd7, 0xfb,
    0x7c, 0xe3, 0x39, 0x82, 0x9b, 0x2f, 0xff, 0x87, 
    0x34, 0x8e, 0x43, 0x44, 0xc4, 0xde, 0xe9, 0xcb,
    0x54, 0x7b, 0x94, 0x32, 0xa6, 0xc2, 0x23, 0x3d, 
    0xee, 0x4c, 0x95, 0x0b, 0x42, 0xfa, 0xc3, 0x4e,
    0x08, 0x2e, 0xa1, 0x66, 0x28, 0xd9, 0x24, 0xb2, 
    0x76, 0x5b, 0xa2, 0x49, 0x6d, 0x8b, 0xd1, 0x25,
    0x72, 0xf8, 0xf6, 0x64, 0x86, 0x68, 0x98, 0x16, 
    0xd4, 0xa4, 0x5c, 0xcc, 0x5d, 0x65, 0xb6, 0x92,
    0x6c, 0x70, 0x48, 0x50, 0xfd, 0xed, 0xb9, 0xda, 
    0x5e, 0x15, 0x46, 0x57, 0xa7, 0x8d, 0x9d, 0x84,
    0x90, 0xd8, 0xab, 0x00, 0x8c, 0xbc, 0xd3, 0x0a, 
    0xf7, 0xe4, 0x58, 0x05, 0xb8, 0xb3, 0x45, 0x06,
    0xd0, 0x2c, 0x1e, 0x8f, 0xca, 0x3f, 0x0f, 0x02, 
    0xc1, 0xaf, 0xbd, 0x03, 0x01, 0x13, 0x8a, 0x6b,
    0x3a, 0x91, 0x11, 0x41, 0x4f, 0x67, 0xdc, 0xea, 
    0x97, 0xf2, 0xcf, 0xce, 0xf0, 0xb4, 0xe6, 0x73,
    0x96, 0xac, 0x74, 0x22, 0xe7, 0xad, 0x35, 0x85, 
    0xe2, 0xf9, 0x37, 0xe8, 0x1c, 0x75, 0xdf, 0x6e,
    0x47, 0xf1, 0x1a, 0x71, 0x1d, 0x29, 0xc5, 0x89, 
    0x6f, 0xb7, 0x62, 0x0e, 0xaa, 0x18, 0xbe, 0x1b,
    0xfc, 0x56, 0x3e, 0x4b, 0xc6, 0xd2, 0x79, 0x20, 
    0x9a, 0xdb, 0xc0, 0xfe, 0x78, 0xcd, 0x5a, 0xf4,
    0x1f, 0xdd, 0xa8, 0x33, 0x88, 0x07, 0xc7, 0x31, 
    0xb1, 0x12, 0x10, 0x59, 0x27, 0x80, 0xec, 0x5f,
    0x60, 0x51, 0x7f, 0xa9, 0x19, 0xb5, 0x4a, 0x0d, 
    0x2d, 0xe5, 0x7a, 0x9f, 0x93, 0xc9, 0x9c, 0xef,
    0xa0, 0xe0, 0x3b, 0x4d, 0xae, 0x2a, 0xf5, 0xb0, 
    0xc8, 0xeb, 0xbb, 0x3c, 0x83, 0x53, 0x99, 0x61,
    0x17, 0x2b, 0x04, 0x7e, 0xba, 0x77, 0xd6, 0x26, 
    0xe1, 0x69, 0x14, 0x63, 0x55, 0x21, 0x0c, 0x7d 
};

/* galois multiplication */
static uint8_t AES_GMul(uint8_t a, uint8_t b)
{
    /* partial result, index, carry bit */
	uint8_t p = 0, i, c;
	
	/* for every bit... */
	for (i = 0; i < 8; i++) {
		if (b & 1) 
            p ^= a;
		/* detect if x^8 term is about to be generated */
		c = a & 0x80;  
		a <<= 1;
		/* replace x^8 with x^4 + x^3 + x + 1 */
		if (c) 
            a ^= 0x1B;
		b >>= 1;
	}
	
	/* return result */
	return p;
}

/* add round key step */
static void AES_AddRoundKey(uint8_t *key, uint8_t *state)
{
	int i;
	/* add round key */
	for (i = 0; i < 16; i++) {
		state[i] ^= key[i];
	}
}

/* bytes substitution */
static void AES_SubBytes(uint8_t *state)
{
	int i;
	/* use normal array */
	for (i = 0; i < 16; i++) {
		state[i] = sbox[state[i]];
	}
}

/* inverse bytes subsitution */
static void AES_InvSubBytes(uint8_t *state)
{
    int i;
	/* use inverse array */
	for (i = 0; i < 16; i++) {
		state[i] = isbox[state[i]];
	}
}

/* shift rows: keep in mind that C uses rows as major indexing, and aes uses 
 * column major indexing so rows become columns and vice-versa */
static void AES_ShiftRows(uint8_t *state)
{
	uint8_t a, b;

	/* first row is left unchanged */
	/* 2nd row - shift left once */
	a = state[1];
	state[1] = state[5];
	state[5] = state[9];
	state[9] = state[13];
	state[13] = a;
	
	/* 3rd row - shift left twice */
    a = state[2]; b = state[6];
    state[2] = state[10];
    state[6] = state[14];
    state[10] = a;
    state[14] = b;

	/* 4th row - shift right once */
	a = state[15];
	state[15] = state[11];
	state[11] = state[7];
	state[7] = state[3];
	state[3] = a;
}

/* inverted shift rows */
static void AES_InvShiftRows(uint8_t *state)
{
    uint8_t a, b;
    
    /* first row is left unchanged */
    /* 2nd row - shift right once */
    a = state[13];
    state[13] = state[9];
    state[9] = state[5];
    state[5] = state[1];
    state[1] = a;
    
    /* 3rd row - shift right twice */
    a = state[10]; b = state[14];
    state[10] = state[2];
    state[14] = state[6];
    state[2] = a;
    state[6] = b;
    
	/* 4th row - shift left once */
	a = state[3];
	state[3] = state[7];
	state[7] = state[11];
	state[11] = state[15];
	state[15] = a;
}

/* mix colums */
static void AES_MixColums(uint8_t *state)
{
	int i, j;
	/* column pointer */
	uint8_t s[4];
	/* matrix */
	uint8_t m[] = { 2, 3, 1, 1,
                    1, 2, 3, 1,
                    1, 1, 2, 3,
                    3, 1, 1, 2 };
    
	/* for every column */
	for (i = 0; i < 4; i++) {
        /* for every element in column */
        for (j = 0; j < 4; j++) {
            /* multiply and add */
            s[j]  = AES_GMul(state[i*4 + 0], m[j*4 + 0]);
            s[j] ^= AES_GMul(state[i*4 + 1], m[j*4 + 1]);
            s[j] ^= AES_GMul(state[i*4 + 2], m[j*4 + 2]);
            s[j] ^= AES_GMul(state[i*4 + 3], m[j*4 + 3]);
        }
		/* write back the result */
		state[i*4 + 0] = s[0]; state[i*4 + 1] = s[1];
		state[i*4 + 2] = s[2]; state[i*4 + 3] = s[3];
	}
}

/* inv mix colums */
static void AES_InvMixColums(uint8_t *state)
{
    int i, j, k;
	/* column storage */
	uint8_t s[4];
	/* matrix */
	uint8_t m[] = { 14, 11, 13,  9,
                     9, 14, 11, 13,
                    13,  9, 14, 11,
                    11, 13,  9, 14 };
    
	/* for every column */
	for (i = 0; i < 4; i++) {
        /* for every element in column */
        for (j = 0; j < 4; j++) {
            /* multiply and add */
            s[j]  = AES_GMul(state[i*4 + 0], m[j*4 + 0]);
            s[j] ^= AES_GMul(state[i*4 + 1], m[j*4 + 1]);
            s[j] ^= AES_GMul(state[i*4 + 2], m[j*4 + 2]);
            s[j] ^= AES_GMul(state[i*4 + 3], m[j*4 + 3]);
        }
		/* write back the result */
		state[i*4 + 0] = s[0]; state[i*4 + 1] = s[1];
		state[i*4 + 2] = s[2]; state[i*4 + 3] = s[3];
	}
}

/* generate expanded key */
void AES_KeySchedule(uint8_t *key, uint8_t *ekey)
{
    /* counters */
	int i, j;
	
	memset(ekey, 0, 176);
	
	/* current key pointer, previous key pointer, temporary storage */
	uint8_t *ck = ekey + 16, *pk = ekey;
	
	/* the first 16 bytes of expanded key are simply the key itself */
	memcpy(ekey, key, 16);
	
	/* we need to generate additional 10 keys */
	for (i = 0; i < 10; i++) {
        /* get last four bytes of previous key, and apply one left shift to it 
         * (RotWord) */
        ck[0] = pk[13]; ck[1] = pk[14]; ck[2] = pk[15]; ck[3] = pk[12];
        /* sub bytes */
        ck[0] = sbox[ck[0]]; ck[1] = sbox[ck[1]]; 
        ck[2] = sbox[ck[2]]; ck[3] = sbox[ck[3]];
        /* do the rcon operation */
        ck[0] ^= rcon[i];
        /* add 1st column from previous key */
        ck[0] ^= pk[0]; ck[1] ^= pk[1]; ck[2] ^= pk[2]; ck[3] ^= pk[3];
        /* three remaining columns are simply a sum of column from previous 
         * key and previous column from current key */
        for (j = 4; j < 16; j+=4) {
            /* sum things up */
            ck[j + 0]  = ck[j - 4 + 0] ^ pk[j + 0];
            ck[j + 1]  = ck[j - 4 + 1] ^ pk[j + 1];
            ck[j + 2]  = ck[j - 4 + 2] ^ pk[j + 2];
            ck[j + 3]  = ck[j - 4 + 3] ^ pk[j + 3];
        }        
        /* update pointers */
        pk = ck; ck += 16;
	}
}

/* perform encryption */
void AES_Encrypt(uint8_t *ekey, uint8_t *state)
{
	/* round number */
	uint8_t round;

	/* initial round  - add key */
	AES_AddRoundKey(ekey, state);
	
	/* 9 main rounds */
	for (round = 1; round <= 9; round++) {
		/* sub bytes */
		AES_SubBytes(state);
		/* shift rows */
		AES_ShiftRows(state);
		/* mix columns */
		AES_MixColums(state);

		/* add round key */
		AES_AddRoundKey(ekey + round * 16, state);
	}

	/* last round */
	AES_SubBytes(state);
	/* shift rows */
	AES_ShiftRows(state);
	/* add round key */
	AES_AddRoundKey(ekey + 160, state);
}

/* perform decryption */
void AES_Decrypt(uint8_t *ekey, uint8_t *state)
{
	/* round number */
	uint8_t round;
	
	/* initial round  - add key */
	AES_AddRoundKey(ekey + 160, state);

	/* 9 main rounds */
	for (round = 9; round > 0; round--) {
        /* inverse shift rows */
        AES_InvShiftRows(state);
        /* inverse sub bytes */
		AES_InvSubBytes(state);
		/* add round key */
		AES_AddRoundKey(ekey + round * 16, state);
		/* inverse mix columns */
		AES_InvMixColums(state);
	}

    /* last round */
    /* inverse shift rows */
    AES_InvShiftRows(state);
    /* inverse sub bytes */
    AES_InvSubBytes(state);
	/* add round key */
	AES_AddRoundKey(ekey, state);
}
